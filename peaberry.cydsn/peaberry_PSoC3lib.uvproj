# Keil uVision project peaberry_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245PVA-150 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: peaberry_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h USBFS.c USBFS.h USBFS_audio.c USBFS_audio.h USBFS_boot.c USBFS_cdc.c USBFS_cdc.h USBFS_cls.c USBFS_descr.c USBFS_drv.c USBFS_episr.c USBFS_hid.c USBFS_hid.h USBFS_pm.c USBFS_std.c USBFS_vnd.c USBFS_cdc.inf USBFS_midi.c USBFS_midi.h I2S.c I2S.h I2S_PM.c USBFS_Dm_aliases.h USBFS_Dp.c USBFS_Dp.h USBFS_Dp_aliases.h Microphone.c Microphone.h Microphone_PM.c Microphone_INT.c Microphone_Ext_CP_Clk.c Microphone_Ext_CP_Clk.h Microphone_AMux.c Microphone_AMux.h USBFS_ep4_dma.c USBFS_ep4_dma.h USBFS_ep5_dma.c USBFS_ep5_dma.h USBFS_ep2_dma.c USBFS_ep2_dma.h USBFS_ep3_dma.c USBFS_ep3_dma.h I2C.c I2C.h I2C_BOOT.c I2C_INT.c I2C_PM.c RxI2S_done_isr.c RxI2S_done_isr.h RxI2S_Buff_dma.c RxI2S_Buff_dma.h RxI2S_Swap_dma.c RxI2S_Swap_dma.h RxI2S_Stage_dma.c RxI2S_Stage_dma.h USBFS_VBUS.c USBFS_VBUS.h USBFS_VBUS_aliases.h TxI2S_Swap_dma.c TxI2S_Swap_dma.h TxI2S_Buff_dma.c TxI2S_Buff_dma.h TxI2S_Stage_dma.c TxI2S_Stage_dma.h pdn_DMA_dma.c pdn_DMA_dma.h pup_DMA_dma.c pup_DMA_dma.h Mic_Buff_dma.c Mic_Buff_dma.h Mic_done_isr.c Mic_done_isr.h RX_REV.c RX_REV.h RX_REV_aliases.h EEPROM.c EEPROM.h TxI2S_Zero_dma.c TxI2S_Zero_dma.h Status.c Status.h IQGen_api.c IQGen_api.h SyncSOF_api.c SyncSOF_api.h
target Release (MCS-51)
  device: CY8C3245PVA-150 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: peaberry_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
